# Keil uVision project Interrupt.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.2.0.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Interrupt
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.5, Drivers:CAN 1.5, Drivers:COMP 1.5, Drivers:DAC 1.5, Drivers:DMA 1.5, Drivers:EBC 1.5, Drivers:EEMPROM 1.5, Drivers:I2C 1.5, Drivers:IWDG 1.5, Drivers:LIB 1.5, Drivers:PORT 1.5, Drivers:POWER 1.5, Drivers:RST_CLK 1.5, Drivers:SSP 1.5, Drivers:TIMER 1.5, Drivers:UART 1.5, Drivers:WWDG 1.5
