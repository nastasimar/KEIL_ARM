# Keil uVision project rstclk.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.2.0.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rstclk +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.0.1, Device:Startup_MDR1986BE9x 1.3.1, Drivers:ADC 1.3.1, Drivers:BKP 1.3.1, Drivers:CAN 1.3.1, Drivers:COMP 1.3.1, Drivers:DAC 1.3.1, Drivers:DMA 1.3.1, Drivers:EBC 1.3.1, Drivers:EEMPROM 1.3.1, Drivers:I2C 1.3.1, Drivers:IWDG 1.3.1, Drivers:LIB 1.3.1, Drivers:PORT 1.3.1, Drivers:POWER 1.3.1, Drivers:RST_CLK 1.3.1, Drivers:SSP 1.3.1, Drivers:TIMER 1.3.1, Drivers:UART 1.3.1
