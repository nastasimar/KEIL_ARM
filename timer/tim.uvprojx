# Keil uVision project tim.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tim
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.2i, Drivers:ADC 2.0.2i, Drivers:BKP 2.0.2i, Drivers:CAN 2.0.2i, Drivers:COMP 2.0.2i, Drivers:DAC 2.0.2i, Drivers:DMA 2.0.2i, Drivers:EBC 2.0.2i, Drivers:EEPROM 2.0.2i, Drivers:I2C 2.0.2i, Drivers:IWDG 2.0.2i, Drivers:PORT 2.0.2i, Drivers:POWER 2.0.2i, Drivers:RST_CLK 2.0.2i, Drivers:SSP 2.0.2i, Drivers:TIMER 2.0.2i, Drivers:UART 2.0.2i
